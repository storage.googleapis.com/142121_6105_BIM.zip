Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-10-22T12:35:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 22 12:35:13 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{D28530AB-4F39-4F44-9F43-DD462E8F7BEB}\ifc * Database version: 5507 * Database creation date: Mon Oct 22 12:35:12 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 22 12:35:12 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 22 12:35:12 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6105 Washbasin faucet, 230 V, 6105:6105 Washbasin faucet, 230 V:311869
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass, Fine Textured - Black
Type - Dimensions(Type) - FaucetNominalDepth: 163.5 mm; FaucetNominalHeight: 205 mm; FaucetNominalWidth: 51 mm; HandShowerNominalDepth: 64.5 mm; HandShowerNominalHeight: 286.5 mm; HandShowerNominalWidth: 46 mm; InletConnectionSize: 16 mm; Projection: 120 mm
Type - Electrical(Type) - Electrical Connection: 230 VAC; Operating Voltage: 230 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6105; ConvergoRefNr: 0087-1809-0123-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 2; VersionDate: 18/10/2018
Type - Green Building Properties(Type) - EAN Number: 6414150027246; EMC Directive: 89/336/EEC; EN Standard: EN 15091; LVI Number: 6116180; Noise Class: I (ISO 3822); NRF Number: 4200044; Protection Class: IP 67; STF Certificate: STF VTT-RTH-00112-11
Type - Identity Data(Type) - Class: Fixed connection, touchless; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;EST;FIN;LVA;LTU;NOR;RUS;UKR;POL; Model: 6105 Washbasin faucet, 230 V; Name_en: 6105 Washbasin faucet, 230 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6105; Product Datasheet: https://www.oras.com/datasheet/6105/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras-electra/product/6105/; Type Name: 6105 Washbasin faucet, 230 V; Usage Group: Toilets for the Disabled;Institutional kitchens;Hospitals
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Afterflow Period: 1; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00388461 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Max Flow Period: 120; Pressure Loss With Flow 01ls: 220000 Pa; Recognition Range: 0 - 40 cm; Spare Parts: https://www.oras.com/en/products/oras-electra/spareparts/SP6105/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, health & Care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6105; Features: Battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6105; Name: 6105 Washbasin faucet, 230 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x165x205 mm / Hand shower: 50x65x290 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6105; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6105 Washbasin faucet, 230 V
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; HandshowerVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0887183 m2; Volume: 0.00256627 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6105: 6105 Washbasin faucet, 230 V; Family and Type: 6105: 6105 Washbasin faucet, 230 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6105: 6105 Washbasin faucet, 230 V; Type Id: 6105: 6105 Washbasin faucet, 230 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
